## Libraries/PX4/Drivers/example/imu_forward/Kconfig
```kconfig
menuconfig DRIVERS_IMU_FORWARD
	bool "imu_forward"
	default n
	---help---
		Enable support for imu_forward
```
